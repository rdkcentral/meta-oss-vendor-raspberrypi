RDEPENDS += "wayland-default-egl"
