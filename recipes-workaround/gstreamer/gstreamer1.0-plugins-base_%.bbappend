DEPENDS += "wayland-default-egl"
RDEPENDS_${PN} += "wayland-default-egl"
