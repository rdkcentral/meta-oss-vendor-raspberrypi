RDEPENDS:${PN} += "wayland-default-egl"
