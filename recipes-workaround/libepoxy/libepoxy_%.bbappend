RDEPENDS_${PN} += "wayland-default-egl"
