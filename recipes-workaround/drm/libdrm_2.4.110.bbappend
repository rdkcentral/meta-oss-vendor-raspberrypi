# Todo: Remove on consuming OSS change (https://github.com/rdkcentral/meta-rdk-oss-reference/pull/153)
# To support Ipk consumption
RPROVIDES:${PN} = "drm"
