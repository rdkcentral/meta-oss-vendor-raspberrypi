#Temporary until westeros.inc get updated to latest in common layer. Refer Comcast jira RDK-49476
include westeros.inc
