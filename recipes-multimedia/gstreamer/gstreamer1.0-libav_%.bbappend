
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0022-yocto-drop-acc-raw-audio-data-according-to-clip-meta-data.patch "
